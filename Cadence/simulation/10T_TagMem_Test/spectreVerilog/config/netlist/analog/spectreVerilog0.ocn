simulator( 'spectreVerilog )
